## base_external/package/client/Config.in
```kconfig
config BR2_PACKAGE_CLIENT
	bool "client"
	help
	  Includes the client application
```
